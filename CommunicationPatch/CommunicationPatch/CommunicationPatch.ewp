# IAR project CommunicationPatch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\Libraries\\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; User\Driver; User\App\inc; User\Link
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CommunicationPatch-V1.0.0.bin
  ILINK.IlinkOutputFile: CommunicationPatch.out
  ILINK.IlinkIcfFile: User\Link\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Doc
    Doc/: CommunicationPatch系统中断分组说明.docx Readme.txt 技术要求-通讯模块补丁.docx
    Doc/EC20模块资料/: EC20 --TCPIP AT指令.pdf EC20透传模式AT指令初始化流程.png Quectel_EC20_AT_Commands_Manual_V1.3(15210567816吕).pdf Quectel_EC20_TCPIP_AT_Commands_Manual_V1.0.pdf
    Doc/电路板/: PCIE_STM32_SCH.pdf PCIE_STM32开发板硬件手册.pdf
    Doc/协议/: 服务器终端通信协议_2017-08-24.docx 硬件设备调试指令集(测试指令)2017-08-10).xlsx
  group FWLib/CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLib/STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/App
    User/App/src/: Core.c Delay.c main.c stm32f10x_it.c
  group User/Driver
    User/Driver/Device_Comm/: Device_Comm.c
    User/Driver/Internal_Flash/: Internal_Flash.c
    User/Driver/MCU/: MCU.c
    User/Driver/Print/: Print.c
    User/Driver/SDCard/: SDCard.c
    User/Driver/Server_Comm/: Server_Comm.c
    User/Driver/WireLessModule/: WireLessModule.c
  group User/Driver/FATFS
    User/Driver/FATFS/source/: diskio.c ff.c ffunicode.c SysFatfs.c
