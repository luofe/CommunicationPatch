<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CommunicationPatch\CommunicationPatch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CommunicationPatch_BootLoader\CommunicationPatch_BootLoader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


